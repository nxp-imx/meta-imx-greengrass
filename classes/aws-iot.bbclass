../../meta-digi/meta-digi-dey/classes/aws-iot.bbclass